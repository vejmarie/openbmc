FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"
DEPENDS += "libtirpc"

